options:
  parameters:
    generate_options: qt_gui
    id: reader
    output_language: python
    title: EE4002D
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: 3.35*100e6/50
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: 3.35*1e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '[1] * 83'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/source
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/matched_filter
    type: complex
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/decoder
    type: complex
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/gate
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/reader
    type: float
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: /home/yeoenghoejason/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/to_complex
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: num_taps
    type: ccc
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: '50'
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: freq
    samp_rate: dac_rate
    serial: 0009072C0288371F
  states: {state: disabled}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: int(dac_rate)
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    num_mboards: ''
    samp_rate: dac_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_2
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    dev_args: '"driver=lime,soapy=0"'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: LNAL
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: adc_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: LNAL
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '"driver=lime,soapy=0"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: adc_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_file_sink_6, '0']
- [blocks_float_to_complex_0, '0', limesdr_sink_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_1, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_2, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', blocks_file_sink_3, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_file_sink_4, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_file_sink_2_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
