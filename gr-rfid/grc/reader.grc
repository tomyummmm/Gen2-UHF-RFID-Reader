options:
  parameters:
    generate_options: qt_gui
    id: reader
    output_language: python
    title: EE4002D
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: 100e6/50
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: blf
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '[1] * int(adc_rate/blf  * 0.5)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/file_sink
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/file_sink
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/file_source_test
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: num_taps
    type: ccc
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: int(dac_rate)
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}

connections:
- [blocks_file_source_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
